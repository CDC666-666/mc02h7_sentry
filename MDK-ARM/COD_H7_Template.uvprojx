# Keil uVision project COD_H7_Template.uvprojx, settings and files
target COD_H7_Template (6190000::V6.19::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: COD_H7_Template +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,__FPU_PRESENT=1U,ARM_MATH_CHECK
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Application/Task/Inc;../Application/Robot/Inc;../Application/RobotCmd/Inc;../Application/Chassis/Inc;../Application/Gimbal/Inc;../Application/Shoot/Inc;../Application/Vision/Inc;../Application/Slam/Inc;../Components/Device/Inc;../Components/Controller/Inc;../Components/Algorithm/Inc;../BSP/Inc;../SystemView/SEGGER/Syscalls;../SystemView/Sample/FreeRTOSV10;../SystemView/Sample/FreeRTOSV10/Patch;../SystemView/Config;../SystemView/SEGGER
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: COD_H7_Template\COD_H7_Template.sct
  group Application/Task
    ../Application/Task/Src/: INS_Task.c Control_Task.c robot_can_task.c Detect_Task.c Telemetry_Task.c
    ../Application/Task/Inc/: Telemetry_Task.h Config.h
  group Application/Robot
    ../Application/RobotCmd/Src/: robot_can.c robot_motor.c
    ../Application/Chassis/Src/: chassis_evo4310_test.c chassis_mecanum.c chassis_omni.c chassis_steering.c chassis_power.c chassis_task.c
    ../Application/Gimbal/Src/: gimbal.c gimbal_big_yaw_small_yaw_pitch.c gimbal_fold_yaw_pitch.c gimbal_task.c
    ../Application/Shoot/Src/: shoot_fric.c shoot_task.c
  group Application/Vision
    ../Application/Vision/Src/: vision_link.c vision_task.c
    ../Application/Vision/Inc/: vision_link.h vision_protocol.h vision_task.h
  group Application/Slam
    ../Application/Slam/Src/: slam.c slam_task.c
    ../Application/Slam/Inc/: slam.h slam_task.h
  group Components/Device
    ../Components/Device/Src/: Motor.c dm4310_can1.c Remote_Control.c Referee_System.c MiniPC.c Bmi088.c
    ../Components/Device/Inc/: Bmi088_Reg.h
  group BSP
    ../BSP/Src/: bsp_can_dm4310.c bsp_uart.c bsp_adc.c bsp_gpio.c bsp_pwm.c bsp_buzzer.c bsp_spi.c bsp_tick.c bsp_mcu.c
  group Components/Controller
    ../Components/Controller/Src/: PID.c
  group Components/Algorithm
    ../Components/Algorithm/Src/: Kalman_Filter.c Quaternion.c LPF.c Ramp.c RLS.c CRC.c
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c bdma.c dma.c fdcan.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group DSP
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM7lfdp_math.lib
  group User/SystemView
    ../SystemView/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
    ../SystemView/Sample/FreeRTOSV10/: SEGGER_SYSVIEW_FreeRTOS.c
    ../SystemView/Sample/FreeRTOSV10/Config/Cortex-M/: SEGGER_SYSVIEW_Config_FreeRTOS.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.6.0
